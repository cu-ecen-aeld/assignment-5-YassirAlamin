## base_external/Config.in
```kconfig
# base_external/Config.in
#aesd-assignments
source "$BR2_EXTERNAL_project_base_PATH/package/aesd-assignments/Config.in"
```
